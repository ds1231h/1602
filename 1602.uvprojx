# Keil uVision project 1602.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1602 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: .\core;.\hardware\inc;.\stlib\inc;.\user
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group usr
    ./user/: main.c stm32f10x_it.c system_stm32f10x.c
  group core
    ./core/: core_cm3.c startup_stm32f10x_cl.s
  group hardware
    ./hardware/src/: delay.c led.c 1602.c sys.c usart.c
  group stlib
    ./stlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_crc.c stm32f10x_usart.c
